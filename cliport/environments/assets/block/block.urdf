Commit message: ready to train and test

File: cliport/environments/assets/block/block.urdf (robot description, URDF)
Before this commit: robot box.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.04 0.04 0.01; visual box size=0.04 0.04 0.01
